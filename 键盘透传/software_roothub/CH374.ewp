# IAR project CH374.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Application; STM32F10x_StdPeriph_Driver\inc; STM32F10x_StdPeriph_Driver; CH374U; STM32_USB-FS-Device_Driver\inc; Custom_HID\inc; OS\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CH374.srec
  ILINK.IlinkOutputFile: CH374.out
  ILINK.IlinkIcfFile: CH374.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c port.c
  group CH374U
    CH374U/: ch374.c ROOTHUB.C
  group Custom_HID/src
    Custom_HID/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group OS/CPU
    OS/Cortexm3/: backtrace.c context_iar.S cpuport.c div0.c showmem.c systick.c
  group OS/Kernel
    OS/Kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group OS/OS_App
    OS/OS_App/: Application.c start_up.c usb0.c usb1.c usb2.c
  group STM32_USB-FS-Device_Driver/src
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/: startup_stm32f10x_md.s system_stm32f10x.c
    Custom_HID/src/: stm32_it.c
  group STM32F10x_StdPeriph_Driver/src
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
